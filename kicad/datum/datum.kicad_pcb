# Repository skuep/pick-placer

File README.md:

Pick-Placer
===========
This is work in progress and highly beta.

Onshape CAD Data is here: https://cad.onshape.com/documents/7a2b90e013ddb4f790097381/w/de934a112d86b578c597cdf9/e/dd9aa8bcdc6310fd48dbadf3?renderMode=0&uiState=67277172a141ee1e785db69c

This is a mix of multiple projects:
---------

- LumenPnP
  - Basic Idea and Toolhead Design
  - Valves, 260mm Belt, Nema 11 Rotation Motors (later switched to Juki style from Robotdigg)
  - Cameras (ELP 720P USB kamera modul CMOS OV9712 mit 6mm Fokus) & ring-lights (slightly modified)
  - Staging plate (modified to measure 90x470)
  - Photon feeder support (mechanical, not tested)
  - Datum board & mount (modified)
  - Toolhead Linear Rails
  
- Voron Trident 350mm
  - Frame Kit (plus a few uncritical saw cuts and blind joint holes using jigs) and Panels
  - X/Y Motors, Belts, MGN12 and MGN9 Rails for X/Y
  - Nema14 stepper motor (~~17HS08-1004S~~ 17HS19-2004S1)
  - Split toolhead carriage design and XY joint design
  - X/Y Drag Chains
  - Idlers (BFI)
  - D2F homing switch PCB
  - Rubber feet
  - DIN Rails
  - Screws & Misc Hardware
  - Belt routing idea (plus some inspiration from VzBoT-330)

Other Parts used:
- Festo CRVZS-0,4 (Used on ebay)
- MGN9C 100mm Rails (CNA on AliExpress)
- Nema17 stepper motor with 20mm thickness (Stepper-Online) for Toolhead
- 500mm length extrusions with V groove for LumenPnP feeder compatibility
- 32 Teeth pulleys

## KiCad design kicad/duet-encdb/duet-encdb.kicad_pcb

Parts:
C1, C3, C4, C6: 10u/10V; C_0805_2012Metric; LCSC C15850
C2, C5: 1u/10V; C_0603_1608Metric; LCSC C15849
H1: MountingHole; MountingHole_2.5mm
J1: Conn_02x05_Odd_Even; PinSocket_2x05_P2.54mm_Vertical
J2, J3: Conn_01x08; JST_XH_B8B-XH-A_1x08_P2.50mm_Vertical
JP1: Jumper_2_Open; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
R1, R2, R3, R4, R5, R6, R13, R14, R15, R16, R17, R18: 100R; R_0603_1608Metric; LCSC C22775
R7, R8, R9, R10, R11, R12: 10K; R_0603_1608Metric; LCSC C25804
U1, U2: LM2775DSG; WSON-8-1EP_2x2mm_P0.5mm_EP0.9x1.6mm_ThermalVias; LCSC C473361
U3: 74LVC541A; TSSOP-20_4.4x6.5mm_P0.65mm; LCSC C6093

Connections:
+3V3: C1.1, C4.1, J1.8, U1.5 (EN), U1.7 (VIN), U2.5 (EN), U2.7 (VIN), U3.20 (VCC)
/ENC1_5V: C3.1, J2.1, JP1.1 (A), U1.6 (VOUT)
/ENC1_A: J1.5, R13.1
/ENC1_B: J1.4, R14.1
/ENC1_N: J1.10, R15.1
/ENC2_5V: C6.1, J3.1, JP1.2 (B), U2.6 (VOUT)
/ENC2_A: J1.7, J1.9, R16.1
/ENC2_B: J1.1, J1.3, R17.1
/ENC2_N: J1.6, R18.1
GND: C1.2, C3.2, C4.2, C6.2, J1.2, J2.2, J3.2, R7.1, R8.1, R9.1, R10.1, R11.1, R12.1, U1.1 (PFM), U1.4 (OUTDIS), U1.8 (GND), U1.9 (GND), U2.1 (PFM), U2.4 (OUTDIS), U2.8 (GND), U2.9 (GND), U3.1 (G1), U3.2 (A0), U3.9 (A7), U3.10 (GND), U3.19 (G2)
unnamed: C2.1, U1.3 (C1+)
unnamed: C2.2, U1.2 (C1-)
unnamed: C5.1, U2.3 (C1+)
unnamed: C5.2, U2.2 (C1-)
unnamed: J2.3, R1.2, R7.2
unnamed: J2.5, R2.2, R9.2
unnamed: J2.7, R3.2, R11.2
unnamed: J3.3, R4.2, R8.2
unnamed: J3.5, R5.2, R10.2
unnamed: J3.7, R6.2, R12.2
unnamed: R1.1, U3.3 (A1)
unnamed: R2.1, U3.4 (A2)
unnamed: R3.1, U3.5 (A3)
unnamed: R4.1, U3.6 (A4)
unnamed: R5.1, U3.7 (A5)
unnamed: R6.1, U3.8 (A6)
unnamed: R13.2, U3.17 (Y1)
unnamed: R14.2, U3.16 (Y2)
unnamed: R15.2, U3.15 (Y3)
unnamed: R16.2, U3.14 (Y4)
unnamed: R17.2, U3.13 (Y5)
unnamed: R18.2, U3.12 (Y6)

Notes on the sheet:
+5V
SPI1_MOSI/PDEC0 (PC16)
GND
SPI1_SCK/PDEC1 (PC17)
SPI1_MISO(PC19)
N/C
SPI1_CS2/EXTINT7 (PA07)
SPI1_CS3/CCLIN09 (PB14)
SPI1_CS0/EXTINT10 (PB10)
SPI1_CS1/CCLIN10 (PB15)

Board: 2 copper layers, 27.0 x 27.0 mm, 32 parts (2 on the bottom side), 32 nets.

File kicad/duet-encdb/jlcpcb/production_files/BOM-duet-encdb.csv:

Comment,Designator,Footprint,LCSC
1u/10V,"C2,C5,C7",C_0603_1608Metric,C15849
10u/10V,"C1,C3,C4,C6",C_0805_2012Metric,C15850
100R,"R1,R2,R3,R4,R5,R6",R_0603_1608Metric,C22775
10K,"R10,R11,R12,R7,R8,R9",R_0603_1608Metric,C25804
LM2775DSG,"U1,U2",WSON-8-1EP_2x2mm_P0.5mm_EP0.9x1.6mm_ThermalVias,C473361
74LVC541A,U3,TSSOP-20_4.4x6.5mm_P0.65mm,C6093
Conn_01x08,J3,JST_XH_B8B-XH-A_1x08_P2.50mm_Vertical,
Conn_01x08,J2,JST_XH_B8B-XH-A_1x08_P2.50mm_Vertical,
Conn_02x05_Odd_Even,J1,PinSocket_2x05_P2.54mm_Vertical,

## KiCad design kicad/toolhead-board/toolhead-board.kicad_pcb

Parts:
C1, C2, C8, C11: 100n; C_0603_1608Metric; LCSC C14663
C3: 4.7u/16V; C_0603_1608Metric; LCSC C19666
C4, C5, C7: 1n; C_0603_1608Metric; LCSC C1588
C6: 1uF/50V; C_0805_2012Metric; LCSC C28323
C9: 10u/50V/X5R; C_1206_3216Metric; LCSC C13585
C10: 22u/10V/X5R; C_1206_3216Metric; LCSC C12891
FB1: 100R; R_0805_2012Metric; LCSC C1015
H2, H3, H5, H6: MountingHole; MountingHole_3.2mm_M3
J1: Conn_02x12_Top_Bottom; Molex_Micro-Fit_3.0_43045-2400_2x12_P3.00mm_Horizontal
J2: ZM; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J3: LM; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J4: RM; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J5: RGB; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J6: VL; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J7: VR; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J8: ZES; JST_PH_B4B-PH-K_1x04_P2.00mm_Vertical
J9: USB_C_Receptacle_USB2.0; MC-711; LCSC C6332301
J10: CAM; JST_PH_B4B-PH-K_1x04_P2.00mm_Vertical
J11: DB9_Male_MountingHoles; DSUB-9_Male_Horizontal_P2.77x2.84mm_EdgePinOffset4.94mm_Hou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
J12: Conn_01x08; JST_XH_S8B-XH-A-1_1x08_P2.50mm_Horizontal
R1, R2, R3, R6, R7, R8, R11, R12, R15, R16: 10R; R_0603_1608Metric; LCSC C22859
R4, R5, R9, R10: 5.1K; R_0603_1608Metric; LCSC C23186
R13: 100K; R_0603_1608Metric; LCSC C25803
R14: 24K; R_0603_1608Metric; LCSC C23352
U1, U2: XGZP6857A100KPGPN; XGZP6857A
U3: MIC5233-5.0YM5-TR; SOT-23-5; LCSC C219988
U4: 74LVC1G17GW; SOT-353_SC-70-5; LCSC C426705
U5: LMZM23601; Texas_SIL0010A_MicroSiP-10-1EP_3.8x3mm_P0.6mm_EP0.7x2.9mm_T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; LCSC C2861484
U6: UA9637; SO-8_3.9x4.9mm_P1.27mm; LCSC C1544610
U7, U8: TLV6001DCK; SOT-353_SC-70-5; LCSC C2059411

Connections:
+5VD: C8.1, C10.1, C11.2, J5.1, J11.7, J12.4, R13.2, U4.5 (VCC), U5.6 (VOUT), U6.1 (VCC)
+24V: FB1.1, J1.8, J6.1, J7.1, R3.2
/A+: J11.6, J12.1, R8.1, U6.6 (IN+)
/A-: J11.1, J12.2, U6.5 (IN-)
/B+: J11.8, J12.6, R7.1, U6.8 (IN+)
/B-: J11.3, J12.5, U6.7 (IN-)
/ENC-A: J1.24, R8.2, R11.2
/ENC-B: J1.12, R7.2, R12.2
/LM-A+: J1.17, J3.1
/LM-A-: J1.5, J3.2
/LM-B+: J1.18, J3.3
/LM-B-: J1.6, J3.4
/PSL: C4.1, J1.21, R1.2, R15.2
/PSR: C5.1, J1.9, R2.2, R16.2
/RGBSIG: J1.10, R6.2, U4.2
/RM-A+: J1.15, J4.1
/RM-A-: J1.3, J4.2
/RM-B+: J1.16, J4.3
/RM-B-: J1.4, J4.4
/SIG: J5.2, U4.4
/USB+5V: J9.A4 (VBUS), J9.A9 (VBUS), J9.B4 (VBUS), J9.B9 (VBUS), J10.4
/USBD+: J9.A6 (D+), J9.B6 (D+), J10.2
/USBD-: J9.A7 (D-), J9.B7 (D-), J10.3
/USBGND: J9.A1 (GND), J9.A12 (GND), J9.B1 (GND), J9.B12 (GND), J9.S1 (SHIELD), J10.1, R4.1, R5.1
/VL: J1.19, J6.2
/VR: J1.7, J7.2
/Z+: J11.9, J12.8
/Z-: J11.5, J12.7
/ZESL: J1.11, J8.1
/ZESR: J1.23, J8.4
/ZM-A+: J1.13, J2.1
/ZM-A-: J1.1, J2.2
/ZM-B+: J1.14, J2.3
/ZM-B-: J1.2, J2.4
GND: C7.2, C8.2, C9.2, C10.2, C11.1, J1.22, J5.3, J8.2, J8.3, J11.0 (PAD), J11.2, J11.4, J12.3, R14.1, U4.1, U4.3 (GND), U5.1 (GND), U5.2 (MODE/SYNC), U5.11 (GND), U6.4 (GND)
GNDA: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, J1.20, R9.1, R10.1, U1.1 (GND), U2.1 (GND), U3.2 (GND), U7.2 (V-), U8.2 (V-)
unnamed: C1.1, C2.1, C3.1, U1.5 (VDD), U2.5 (VDD), U3.5 (OUT), U7.5 (V+), U8.5 (V+)
unnamed: C6.1, R3.1, U3.1 (IN), U3.3 (EN)
unnamed: C7.1, R6.1
unnamed: C9.1, FB1.2, U5.3 (VIN), U5.4 (EN)
unnamed: J9.A5 (CC1), R5.2
unnamed: J9.B5 (CC2), R4.2
unnamed: R1.1, U7.3 (-), U7.4
unnamed: R2.1, U8.3 (-), U8.4
unnamed: R10.2, R16.1, U2.4 (OUT), U8.1 (+)
unnamed: R11.1, U6.3 (OUT)
unnamed: R12.1, U6.2 (OUT)
unnamed: R13.1, R14.2, U5.7 (FB)
unnamed: R9.2, R15.1, U1.4 (OUT), U7.1 (+)

Board: 2 copper layers, 47.5 x 65.0 mm, 52 parts (0 on the bottom side), 49 nets.

File kicad/toolhead-board/jlcpcb/production_files/BOM-toolhead-board.csv:

Comment,Designator,Footprint,LCSC
100R,FB1,R_0805_2012Metric,C1015
22u/10V/X5R,C10,C_1206_3216Metric,C12891
10u/50V/X5R,C9,C_1206_3216Metric,C13585
100n,"C1,C11,C2,C8",C_0603_1608Metric,C14663
UA9637,U6,SO-8_3.9x4.9mm_P1.27mm,C1544610
1n,"C4,C5",C_0603_1608Metric,C1588
4.7u/16V,C3,C_0603_1608Metric,C19666
TLV6001DCK,"U7,U8",SOT-353_SC-70-5,C2059411
MIC5233-5.0YM5-TR,U3,SOT-23-5,C219988
10R,"R1,R11,R12,R15,R16,R2,R3,R6,R7,R8",R_0603_1608Metric,C22859
5.1K,"R10,R4,R5,R9",R_0603_1608Metric,C23186
24K,R14,R_0603_1608Metric,C23352
100K,R13,R_0603_1608Metric,C25803
1uF/50V,C6,C_0805_2012Metric,C28323
LMZM23601,U5,Texas_SIL0010A_MicroSiP-10-1EP_3.8x3mm_P0.6mm_EP0.7x2.9mm_ThermalVias,C2861484
74LVC1G17GW,U4,SOT-353_SC-70-5,C426705
USB_C_Receptacle_USB2.0,J9,MC-711,C6332301
MountingHole,H3,MountingHole_3.2mm_M3,
MountingHole,H2,MountingHole_3.2mm_M3,
CAM,J10,JST_PH_B4B-PH-K_1x04_P2.00mm_Vertical,
RGB,J5,JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical,
XGZP6857A100KPGPN,U2,XGZP6857A,
ZES,J8,JST_PH_B4B-PH-K_1x04_P2.00mm_Vertical,
MountingHole,H5,MountingHole_3.2mm_M3,
VR,J7,JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,
Conn_01x08,J12,JST_XH_S8B-XH-A-1_1x08_P2.50mm_Horizontal,
DB9_Male_MountingHoles,J11,DSUB-9_Male_Horizontal_P2.77x2.84mm_EdgePinOffset4.94mm_Housed_MountingHolesOffset7.48mm,
VL,J6,JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,
XGZP6857A100KPGPN,U1,XGZP6857A,
MountingHole,H6,MountingHole_3.2mm_M3,
Conn_02x12_Top_Bottom,J1,Molex_Micro-Fit_3.0_43045-2400_2x12_P3.00mm_Horizontal,
RM,J4,JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical,
ZM,J2,JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical,
LM,J3,JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical,

## KiCad design kicad/vacuum-sensor/vacuum-sensor.kicad_pcb

Parts:
C1, C2: 100n; C_0603_1608Metric; LCSC C14663
C3: 4.7u/16V; C_0603_1608Metric; LCSC C19666
C4: 1uF/50V; C_0805_2012Metric; LCSC C28323
C5, C6: 1n; C_0603_1608Metric; LCSC C1588
J1: Conn_01x04; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J2: Conn_01x04; JST_XH_S4B-XH-A_1x04_P2.50mm_Horizontal
R1, R2, R3: 10R; R_0805_2012Metric; LCSC C17415
U1, U2: XGZP6857A100KPGPN; XGZP6857A
U3: MIC5233-5.0YM5-TR; SOT-23-5; LCSC C219988

Connections:
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, J1.4, J2.4, U1.1 (GND), U2.1 (GND), U3.2 (GND)
unnamed: C1.1, C2.1, C3.1, U1.5 (VDD), U2.5 (VDD), U3.5 (OUT)
unnamed: C4.1, R1.1, U3.1 (IN), U3.3 (EN)
unnamed: C5.1, J1.2, J2.2, R2.2
unnamed: C6.1, J1.3, J2.3, R3.2
unnamed: J1.1, J2.1, R1.2
unnamed: R2.1, U1.4 (OUT)
unnamed: R3.1, U2.4 (OUT)

Board: 2 copper layers, 38.0 x 14.0 mm, 13 parts (0 on the bottom side), 8 nets.

File kicad/vacuum-sensor/jlcpcb/production_files/BOM-vacuum-sensor.csv:

Comment,Designator,Footprint,LCSC
100n,"C1,C2",C_0603_1608Metric,C14663
1n,"C5,C6",C_0603_1608Metric,C1588
10R,"R1,R2,R3",R_0805_2012Metric,C17415
4.7u/16V,C3,C_0603_1608Metric,C19666
MIC5233-5.0YM5-TR,U3,SOT-23-5,C219988
1uF/50V,C4,C_0805_2012Metric,C28323
Conn_01x04,J1,JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical,
XGZP6857A100KPGPN,U2,XGZP6857A,
XGZP6857A100KPGPN,U1,XGZP6857A,

## KiCad design kicad/z-endstop/z-endstop.kicad_pcb

Parts:
FID1, FID2: Fiducial; Fiducial_1mm_Mask2mm
H1, H2: MountingHole; MountingHole_2.2mm_M2_DIN965_Pad_TopOnly
J1, J2, J4, J5, J6, J7: Conn_01x01; TestPoint_Pad_3.0x3.0mm
J3: Conn_01x04; JST_PH_B4B-PH-K_1x04_P2.00mm_Vertical

Connections:
unnamed: J1.1, J3.4
unnamed: J3.1, J7.1
unnamed: J3.2, J5.1
unnamed: J3.3, J4.1

Board: 2 copper layers, 42.5 x 10.2 mm, 11 parts (2 on the bottom side), 4 nets.

## KiCad design kicad/ring-light/ringLight.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C9: 100nF; C_0805_2012Metric; Part # CC0805KRX7R9BB104; JLCPCB C49678
D1, D2, D3, D4, D5, D6, D7, D8: WS2812B; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm; Part # WS2812B; LCSC C2843785
FID1, FID2, FID3: Fiducial; Fiducial_1mm_Mask2mm
J1: Connector Top; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical; Part # B3B-XH-A(LF)(SN); JLCPCB C144394
J2: Connector Bot; JST_XH_S3B-XH-A-1_1x03_P2.50mm_Horizontal; Part # S3B-XH-A-1(LF)(SN); JLCPCB C163036
R1: 100R; R_0805_2012Metric; Part # 0805W8F1000T5E; LCSC C17408
U1: 74LVC1G17GW; SOT-353_SC-70-5; LCSC C426705

Connections:
+5V: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C9.1, D1.1 (VDD), D2.1 (VDD), D3.1 (VDD), D4.1 (VDD), D5.1 (VDD), D6.1 (VDD), D7.1 (VDD), D8.1 (VDD), J1.2, J2.2, U1.5 (VCC)
Data_In_3V3: J1.1, J2.1, R1.2
Data_In_5V: D1.4 (DIN), U1.4
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C9.2, D1.3 (VSS), D2.3 (VSS), D3.3 (VSS), D4.3 (VSS), D5.3 (VSS), D6.3 (VSS), D7.3 (VSS), D8.3 (VSS), J1.3, J2.3, U1.1, U1.3 (GND)
unnamed: D1.2 (DOUT), D2.4 (DIN)
unnamed: D2.2 (DOUT), D3.4 (DIN)
unnamed: D3.2 (DOUT), D4.4 (DIN)
unnamed: D4.2 (DOUT), D5.4 (DIN)
unnamed: D5.2 (DOUT), D6.4 (DIN)
unnamed: D6.2 (DOUT), D7.4 (DIN)
unnamed: D7.2 (DOUT), D8.4 (DIN)
unnamed: R1.1, U1.2

Board: 2 copper layers, 40.0 x 50.2 mm, 35 parts (8 on the bottom side), 12 nets.

Other parts of the board:
LOGO: LOGO; logo
kibuzzard-61F2BC8D, kibuzzard-61F2BC8D#2: G***; kibuzzard-61F2BC8D
kibuzzard-61F2BC9E, kibuzzard-61F2BC9E#2: G***; kibuzzard-61F2BC9E
kibuzzard-61F2BC96, kibuzzard-61F2BC96#2: G***; kibuzzard-61F2BC96
kibuzzard-61F2BEFE: G***; kibuzzard-61F2BEFE
kibuzzard-61F2BF3C: G***; kibuzzard-61F2BF3C
kibuzzard-61F2BF4A: G***; kibuzzard-61F2BF4A
kibuzzard-61F2BF10: G***; kibuzzard-61F2BF10
svg2mod: n/a; label

## Commit log

2024-07-31 Added ring-light PCB
2024-07-31 Modified staging plate dimensions
2024-07-31 Added datum board
2024-08-04 Generation of production data
2024-08-06 Changed buffer to schmitt trigger type
2024-08-10 Added daughterboard for dual encoder
2024-08-10 Added vacuum sensor board for toolhead
2024-08-10 Added step file to encoder daughterboard
2024-08-10 Added second optionalk connector
2024-08-10 Minor changes
2024-08-13 Changed to 1.6mm thickness as that is enough and easy to source
2024-08-21 Added Z-endstop PCB
2024-10-20 Fixed orientation
2024-11-01 Initial commit toolhead board
2024-11-02 Added RS422 receiver
2024-11-02 Final touches and gerber data generation
2024-11-03 Moved mounting holes
2024-11-03 Correct footprint for 0603 resistor
2024-11-03 3D export
2024-11-08 Added EncDB schematic
2024-11-08 Update README.md
    Formatting
2024-11-09 Bumped to RevB, added series resistors to 10 pin header to not short out SPI pins during initialization
2024-11-14 Changed pinout of header, because for the CCL decoder to work, we need to place A and B signals on CCLIN and EXTINT pins simultaneously
2024-12-22 Removed C7 on RGB line
2024-12-22 Changed naming of ENC0/1 to ENC1/2
2025-03-20 Added small staging plate
2025-03-20 Added small plate with cam breakout
2025-12-24 Switched to 0.5mm fiducial
